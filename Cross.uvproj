# Keil uVision project Cross.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: Cross +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Cross
  group Source Group 1
    ./: STARTUP.A51 main.c field.h
